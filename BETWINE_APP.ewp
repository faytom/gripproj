# IAR project BETWINE_APP.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_DMA=TRUE; HAL_LED=TRUE; POWER_SAVING
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: common; components\ble\controller; components\ble\hci; components\ble\include; components\hal\include; components\osal\include; profiles\common; profiles\betwine; profiles\wechat
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  postbuild: "config\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "Debug\Exe\BetwineAPP"
  XLINK.XclFile: C:\Users\Tom\Desktop\新我握力器\0827\config\cc254x_f256_imgB.xcl
configuration Release (8051)
  as the first configuration, except:
  A8051.ADefines: NDEBUG
  postbuild: "config\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "Release\Exe\BETWINE_APP"
  XLINK.XclFile: C:\Users\Tom\Desktop\0827\config\cc254x_f256_imgB.xcl
  group APP
    app/: app.c app.h betwine.c betwine.h betwine_main.c epb.c epb.h epb_MmBp.c epb_MmBp.h epb_WristBand.c epb_WristBand.h oad.h OSAL_betwine.c
  group BLE
    components/ble/include/: att.h bcomdef.h gap.h gatt.h gatt_uuid.c gatt_uuid.h hci.h l2cap.h linkdb.h sm.h
    components/ble/controller/: ll.h phy.h
  group HAL/COMMON
    components/hal/common/: hal_drivers.c hal_startup.c
  group HAL/DRIVERS
    components/hal/drivers/: hal_acc.c hal_adc.c hal_aes.c hal_assert.c hal_crc.c hal_dma.c hal_flash.c hal_i2c.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/INCLUDE
    components/hal/include/: hal_acc.h hal_adc.h hal_aes.h hal_assert.h hal_board.h hal_board_cfg.h hal_ccm.h hal_crc.h hal_defs.h hal_dma.h hal_drivers.h hal_flash.h hal_i2c.h hal_key.h hal_lcd.h hal_led.h hal_mcu.h hal_rpc.h hal_sleep.h hal_timer.h hal_types.h hal_uart.h MMA8652FC.h
  group LIB
    lib/: CC2541_BLE_peri.lib CC254x_BLE_HCI_TL_None.lib
  group OSAL
    components/osal/drivers/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c osal_snv.c OSAL_Timers.c
  group PROFILES
    profiles/betwine/: battservice.c battservice.h historystep.c historystep.h hitpoint.c hitpoint.h motorrun.c motorrun.h pedometer.c pedometer.h systemtest.c systemtest.h timeset.c timeset.h
    profiles/common/: devinfoservice.c devinfoservice.h gap.c gapbondmgr.c gapbondmgr.h gapgattserver.h gattservapp.h peripheral.c peripheral.h
    profiles/wechat/: wechatprofile.c wechatprofile.h
  group TOOLS
    config/: buildComponents.cfg buildConfig.cfg
    common/: OnBoard.c OnBoard.h
